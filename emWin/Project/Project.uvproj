# Keil uVision project Project.uvproj, settings and files
target Project (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx
  c include: ..\Project;..\Refer\inc;..\EMWIN\STemWin\Config;..\EMWIN\STemWin\OS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Project
    ./: main.c startup_stm32f40_41xxx.s
  group Refer
    ../Refer/src/: holl.c usart.c delay.c sys.c tftlcd.c
  group emWin_Conng
    ../EMWIN/STemWin/Config/: GUI_X_Touch_Analog.c GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c LCDConf_Lin_Template.c
  group emWin_LIB
    ../EMWIN/STemWin/Lib/: STemWin526_CM4_Keil.lib
